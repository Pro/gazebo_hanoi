Commit message: Use boxes for collision

File: urdf/materials.xacro (robot description, xacro)
@@ -25,3 +25,6 @@
         <color rgba="1.0 1.0 1.0 1.0"/>
     </material>
+    <material name="Purple">
+        <color rgba="0.5 0 0.5 1"/>
+    </material>
 </robot>
